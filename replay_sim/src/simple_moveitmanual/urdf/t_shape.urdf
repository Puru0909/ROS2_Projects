Commit message: urdf

File: replay_sim/src/simple_moveitmanual/urdf/t_shape.urdf (robot description, URDF)
Before this commit: robot t_shape, 3 links, 2 joints
Links:
- link horizontal_bar: mass 0.02 -> 0.1
- link vertical_bar: mass 0.05 -> 0.2
